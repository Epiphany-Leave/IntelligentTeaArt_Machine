# Keil uVision project tea2.uvprojx, settings and files
target tea2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: tea2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;./BSP;./APP;./driver;./TimePiece;./utils;./Middlewares/LetterShell;./Middlewares/WIFI;./Middlewares/MQTT;./Middlewares/icode;./Middlewares/HMI;./Middlewares/cJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group APP
    ./APP/: commond.h app.c Tim_interrupt.c Uart_interrupt.c
  group Timepiece
    ./TimePiece/: TaskList.c TaskList.h timepiece.c timepiece.h
  group Driver
    ./driver/: adc_driver.c adc_driver.h key_driver.c key_driver.h pwm_driver.c pwm_driver.h beep_driver.c beep_driver.h stp_driver.c stp_driver.h motor_driver.c motor_driver.h
  group BSP
    ./BSP/: adc_bsp.c adc_bsp.h key_bsp.c key_bsp.h pwm_bsp.c pwm_bsp.h
  group Utils
    ./utils/: vofa.c vofa.h
  group Middleware/LetterShell
    ./Middlewares/LetterShell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
  group Middleware/HMI
    ./Middlewares/HMI/: HMI.c HMI.h
  group Middleware/WiFi
    ./Middlewares/WIFI/: wifi.c wifi.h
  group Middleware/cJSON
    ./Middlewares/cJSON/: cJSON.c cJSON.h
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
